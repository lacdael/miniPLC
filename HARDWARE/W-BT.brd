# Repository lacdael/miniPLC

File README.md:

---
title: Controller Documentation
date: 2020-01-29
---

## Key Features:

The **Controller** is a designed for purpose controller board, intended for use with non-critical applications that would benefit from automation. Protected connections and an industrial operational temperature range means that the device can be put to use in harsh environments.

## Specification

*   Industrial operating temperature range
*   8 x protected analogue 0-5v input ports
*   8 x protected digital output ports
*   2 x protected digital input ports
*   1 x Communication port
*   Bluetooth v4 connectivity
*   Small package
*   Small current draw
*   Simple to customize to suit an application

## Controller Operation:

The controller works by routinely evaluating logic that has been sent to it. The controller can be used with various third party interfaces, but all that is needed to get going is a Bluetooth connection via which to send a string of logic.

## Controller Logic:

The logic the device evaluates is made up of a condition to be satisfied and a resulting action. The logic can utilize any of the available inputs and outputs on the device.

e.g. Logic for a simple access control system, where a password must be sent to the controller.

`IF COM = password OR COM = passw0rd THEN O1 = 1 ELSE O1 = 0`

Here, output number #1 "O1", would be wired up to a 5 volt relay connected to an actuator locking mechanism.

e.g. Logic for switching from a solar system to mains supply and back again depending on load.

`IF A1 < 11.5 AND I1 = 1 THEN O1 = 1 ELSE O1 = 0`

`IF A1 > 13 AND I1 = 1 THEN O1 = 0 ELSE O1 = 1`

Here, analogue input #1 `A1` would be a proportionally divided down voltage input from a battery store of a solar system. Digital input #1 `I1` would be a manually operated switch, output #1 `O1` would be connected to a double throw 5 volt relays, rated to 240AC, which would switch between wholesale electricity supply and solar electricity supply.

## Key Words:

| Word    | Description                                                                            |
|---------|----------------------------------------------------------------------------------------|
| HELP    | Get a help string from the microcontroller.                                            |
| NAME    | Set the name of the device. `NAME  a_name`                                             |
| TIMEOUT | Set the timeout to clear the stored string. `TIMEOUT 3`                                |
| LOGIC   | Get a list of all the stored logic strings. `LOGIC`                                    |
| DELETE  | Delete a logic string from the list of stored logic strings. `DELETE 2`                |
| ZERO    | Zero the value of an analogue input. `ZERO A1`                                         |
| GET     | Get the values and setting of the device.                                              |
| SET     | Set a value of an output or calibrate an analogue input. `SET O1 = 1` , `SET A1 = 200` |
| SLAVE   | Turn off logic string evaluation.                                                      |
| MASTER  | Turn on logic string evaluation.                                                       |
| STREAM  | Toggle streaming of the device values.                                                 |
| STR     | Stored string value read from the Bluetooth connection.                                |
| NONE    | A blank string.                                                                        |
| IF      | Used at the start of a ternary logic string.                                           |
| THEN    | Implication. Used in a logic string.                                                   |
| ELSE    | Alternative implication. Used in a logic string.                                       |
| AND     | And conditional. Used in a logic string.                                               |
| OR      | Or conditional. Used in a logic string.                                                |
| !=      | Not equal to. Used in a logic string.                                                  |
| =       | Equal to. Used in a logic string.                                                      |
| >       | Greater than. Used in a logic string.                                                  |
| <       | Less than. Used in a logic string.                                                     |
| O1      | Name for output #1                                                                     |
| O2      | Name for output #2                                                                     |
| O3      | Name for output #3                                                                     |
| O4      | Name for output #4                                                                     |
| O5      | Name for output #5                                                                     |
| O6      | Name for output #6                                                                     |
| O7      | Name for output #7                                                                     |
| O8      | Name for output #8                                                                     |
| A1      | Name for analogue input #1                                                             |
| A2      | Name for analogue input #2                                                             |
| A3      | Name for analogue input #3                                                             |
| A4      | Name for analogue input #4                                                             |
| A5      | Name for analogue input #5                                                             |
| A6      | Name for analogue input #6                                                             |
| A7      | Name for analogue input #7                                                             |
| A8      | Name for analogue input #8                                                             |
| I1      | Name for input #1                                                                      |
| I2      | Name for input #2                                                                      |

## EAGLE design HARDWARE/W-BT.brd

Parts:
C8, C9: 1uF; C0402
C10, C11, C15, C16, C17, C18, C19, C20, C21, C22: 100nF; C0402
C12, C13: 0.1uF; C0402
C14: 10uF; C0402
CBST1: C0603C104Z3VACTU; 0603
CBST2: GRM155R71A104KA01D; 0402
CIN: C2012X5R1V226M125AC; 0805
CINX: GMK212BJ474KG-T; 0805
COUT: C2012X5R1V226M125AC; 0805
CO_SENSE: C2012X7R1H104K085AA; 0805
CVREG: GRM155R61A475MEAAD; 0402
D1: SCHOTTKY-DIODESMD; SMB
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: 3v3; SOD323
FU1: 1A; MF-SMDF050
L1: XAL5030-472MEB; XAL5030
R1, R2, R3, R4, R5, R11, R13, R15, R17, R19, R21: 1K; R0402
R6, R7, R9: 10K; R0402
R8, R10, R12, R14, R16, R18, R20, R22: 2K; R0402
REG1: NCP4620HSN50T1G; SOT95P280X145-5N
RPG: ERJ-6ENF1003V; 0805
T1: ULN2803ADWRG4; SOIC127P1030X265-18N
TP1, TP2, TP4: PTR1TP13R; TP13R
TP5: PTR1TP13SQ; TP13SQ
U1: BM71BLES1FC2-0B02AA; BM71BLES1FC2_1
U2: Value; PWP0020P_N
U3: PIC32MM0064GPL028-I_SS; SOP65P780X200-28N
X1: W237-102
X2, X3, X4, X5: TERMINAL-BLOCK-3.5MM-8-PIN-LONG-PAD; TERMINAL-BLOCK-8-PIN-3.5MM-LONG-PAD
X6: TERMINAL-BLOCK-3.5MM-2-PIN-LONG-PAD; TERMINAL-BLOCK-2-PIN-3.5MM-LONG-PAD

Connections:
3V3: C9.1, C12.2, C13.1, REG1.5 (VOUT), TP4.TP, U1.14 (VBAT), U3.13 (VDD), U3.28 (AVDD)
5V: C8.1, COUT.1, CO_SENSE.1, REG1.1 (VIN), REG1.3 (CE), RPG.2, U2.16 (VOUT_SENSE), U2.17 (VOUT), X2.2, X2.4, X2.6, X2.8, X3.2, X3.4, X3.6, X3.8
A1: R7.1, X2.1
A2: R9.1, X2.3
A3: R11.1, X2.5
A4: R13.1, X2.7
A5: R15.1, X3.1
A6: R17.1, X3.3
A7: R19.1, X3.5
A8: R21.1, X3.7
ADC1: C15.1, D2.1 (C), R7.2, R8.1, U3.23 (RP12/RB12)
ADC2: C16.1, D3.1 (C), R9.2, R10.1, U3.24 (RP13/RB13)
ADC3: C17.1, D4.1 (C), R11.2, R12.1, U3.10 (CLKO/RP4/RA3)
ADC4: C18.1, D5.1 (C), R13.2, R14.1, U3.9 (CLKI/RP3/RA2)
ADC5: C19.1, D6.1 (C), R15.2, R16.1, U3.7 (RB3)
ADC6: C20.1, D7.1 (C), R17.2, R18.1, U3.6 (RP16/RB2)
ADC7: C21.1, D8.1 (C), R19.2, R20.1, U3.3 (RP2/RA1)
ADC8: C22.1, D9.1 (C), R21.2, R22.1, U3.2 (RP1/RA0)
GND: C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, CIN.2, CINX.2, COUT.2, CO_SENSE.2, CVREG.2, D1.A, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), R1.2, R8.2, R10.2, R12.2, R14.2, R16.2, R18.2, R20.2, R22.2, REG1.2 (GND), T1.9 (GND), U1.2 (GND_1), U1.13 (GND_2), U2.1 (PGND), U2.7 (PS), U2.8 (IGN_PWRL), U2.9 (SS_EN), U2.10 (PG_DLY), U2.13 (GND_2), U2.14 (VOS_FB), U2.18 (GND), U2.21 (PAD), U3.8 (VSS), U3.27 (AVSS), X1.2, X4.2, X4.4, X4.6, X4.8, X5.2, X5.4, X5.6, X5.8
I1: R2.2, X6.1
I2: R4.2, X6.2
IN: CIN.1, CINX.1, D1.C, FU1.2, T1.10 (COM), U2.4 (VINP), U2.5 (VINL), U2.6 (IGN)
IN1: R3.1, U3.21 (PGED2/RP17/RB10)
IN2: R5.1, U3.22 (PGEC2/RP18/RB11)
MCLR: R6.1, TP5.TP, U3.1 (!MCLR)
unnamed: CBST2.1, U2.19 (BST2)
unnamed: CBST2.2, L1.1, U2.20 (L2)
unnamed: CBST1.1, U2.3 (BST1)
unnamed: CBST1.2, L1.2, U2.2 (L1)
unnamed: CVREG.1, U2.11 (VREG_Q), U2.12 (VREG)
unnamed: C14.2, U3.20 (VCAP)
O1: T1.11 (8C), X5.1
O2: T1.12 (7C), X5.3
O3: T1.13 (6C), X5.5
O4: T1.14 (5C), X5.7
O5: T1.15 (4C), X4.1
O6: T1.16 (3C), X4.3
O7: T1.17 (2C), X4.5
O8: T1.18 (1C), X4.7
OUT1: T1.8 (8B), U3.15 (PGEC3/RB6)
OUT2: T1.7 (7B), U3.16 (RP11/RB7)
OUT3: T1.6 (6B), U3.17 (RP7/RB8)
OUT4: T1.5 (5B), U3.18 (RP8/RB9)
OUT5: T1.4 (4B), U3.19 (RP19/RC9)
OUT6: T1.3 (3B), U3.14 (PGED3/RB5)
OUT7: T1.2 (2B), U3.12 (SOSCO/RP6/RA4)
OUT8: T1.1 (1B), U3.11 (SOSCI/RP5/RB4)
PGC1: TP1.TP, U3.5 (PGEC1/RP15/RB1)
PGD1: TP2.TP, U3.4 (PGED1/RP14/RB0)
R18LEG: C10.1, D10.1 (C), R2.1, R3.2
R20LEG: C11.1, D11.1 (C), R4.1, R5.2
RAW: FU1.1, X1.1
RESET: R1.1, R6.2, RPG.1, U1.10 (RST_N), U2.15 (PG)
RX: U1.8 (HCI_TXD), U3.26 (RP10/RB15)
TX: U1.7 (HCI_RXD), U3.25 (RP9/RB14)

Notes on the sheet:
POWER MANAGEMENT
INPUTS
ADC INPUTS
OUTPUTS
MICRO-PROCESSOR
COMMS

Board: 2 copper layers, 72.0 x 32.0 mm, 73 parts (0 on the bottom side), 55 nets.

## EAGLE design HARDWARE/DOCS/ExportFiles/Board/Eagle/2018-10-31_17-33-27/2018-10-31_17-33-27.brd

File HARDWARE/DOCS/ExportFiles/Board/Eagle/2018-10-31_17-33-27/readme.txt (part):

**********************************************************
*************  Important Instructions Follow  ************
**********************************************************
 
All files exported to: Z:\\39\\76\\3976910\\2\Eagle\2018-10-31_17-33-27\2018-10-31_17-33-27.xml

**********************************************************
*****************Schematic Instructions  *******************
**********************************************************

To import your new Schematic file into Eagle:

1. Unzip the downloaded folder files to local directory and Start Eagle.
2. Select "File"->"Open"->"Schematic..." from the menu at the top of
the screen.
3. Browse to your newly exported file and select the ".sch" file extension.
4. You should now see your schamtic available in Eagle.

**********************************************************
*******************  PCB Instructions  *******************
**********************************************************

To import your new BOARD file into Eagle:

1. Unzip the downloaded folder files to local directory and Start Eagle.
2. Select "File"->"Open"->"Board..." from the menu at the top of
the screen.
3. Browse to your newly exported file and select the ".brd" file extension.
4. Planes will need to be repoured to update the polygon fills
	1. Once your board is loaded, type "ratsnest" into the command
	   line and press the Enter key.
	2. The polygons should all be filled now.
5. You should now have an image of your board available in Eagle.

**********************************************************
*******************  LIB Instructions  *******************
**********************************************************

To import your new library into Eagle:

1. Start Eagle.
2. Select "File"->"New"->"Library" from the menu.
3. In the blank library window, select "File" -> "Execute Script"
from the menu.
5. Browse to your newly exported Eagle Script file (".scr" file extension)
6. After opening the file, the script will populate the new library.
Layer 93 should NOT exist.
7. Use "File"->Save As: "AcceleratedDesigns_Lib.lbr" and to the desired
location in Eagle native format.
8. Update schematic with the imported library, Select Library and click on Update; open the library file
	and sync. each part.

For additional information, please visit this site:
http://www.accelerated-designs.com/help/Eagle_import.html

You may also find this video helpful:
http://youtu.be/5jGuWY-Yy3Q

**********************************************************
**********************************************************
**********************************************************

Component "C0603C104Z3VACTU" renamed to "C0603C104Z3VACTU"
Component "GRM155R71A104KA01D" renamed to "GRM155R71A104KA01D"
Component "C2012X7R1H104K085AA" renamed to "C2012X7R1H104K085AA"
Component "GMK212BJ474KG-T" renamed to "GMK212BJ474KG-T"
Component "C2012X5R1V226M125AC" renamed to "C2012X5R1V226M125AC"
Component "GRM155R61A475MEAAD" renamed to "GRM155R61A475MEAAD"
Component "ERJ-6ENF1003V" renamed to "ERJ-6ENF1003V"
Component "XAL5030-472MEB" renamed to "XAL5030-472MEB"
Component "CRCW06039K09FKEA" renamed to "CRCW06039K09FKEA"
Component "CRCW060382K5FKEA" renamed to "CRCW060382K5FKEA"
Component "TPS55165QPWPRQ1" renamed to "TPS55165QPWPRQ1"
Component "TP-1502" renamed to "TP-1502"

Ultra Librarian Gold 8.1.204 Process Report

Message - Padstack "RX26Y38D0T" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "RX22Y24D0T" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "RX44Y57D0T" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "RX46Y183D0T" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "R10180550000200A" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "R11342560006666A" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "R10180630000200A" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "R11342560006767A" Shape(4) is a CIRCLE with no diameter.
Message - Padstack "R10160470000200A" Shape(4) is a CIRCLE with no diameter.
Message - Component "C0603C104Z3VACTU" attribute "Cap" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C0603C104Z3VACTU" attribute "ESR" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C0603C104Z3VACTU" attribute "IRMS" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C0603C104Z3VACTU" attribute "VDC" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GRM155R71A104KA01D" attribute "Cap" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GRM155R71A104KA01D" attribute "ESR" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GRM155R71A104KA01D" attribute "IRMS" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GRM155R71A104KA01D" attribute "VDC" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X7R1H104K085AA" attribute "Datasheet URL" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X7R1H104K085AA" attribute "Cap" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X7R1H104K085AA" attribute "ESR" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X7R1H104K085AA" attribute "IRMS" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X7R1H104K085AA" attribute "VDC" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GMK212BJ474KG-T" attribute "Cap" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GMK212BJ474KG-T" attribute "ESR" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GMK212BJ474KG-T" attribute "IRMS" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GMK212BJ474KG-T" attribute "VDC" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X5R1V226M125AC" attribute "Datasheet URL" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X5R1V226M125AC" attribute "Cap" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X5R1V226M125AC" attribute "ESR" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X5R1V226M125AC" attribute "IRMS" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "C2012X5R1V226M125AC" attribute "VDC" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
Message - Component "GRM155R61A475MEAAD" attribute "Datasheet URL" references text style "" that is not in the database.
The default pattern text style "H50s3" was substituted.
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
Board: 4 copper layers, 23 parts (3 on the bottom side), 14 nets.

Parts:
Cbst1: 0603
Cbst2: 0402
Cin: 0805
Cinx: 0805
Co_sense: 0805
Cout: 0805
Cvreg: 0402_065
GND, GND1: TP-1502
L1: XAL5030
Rfb: 0805
Rfbb: 0805
Rfbt: 0805
Rpg: 0805
TP_Delay: TP-1502
TP_FB: TP-1502
TP_IGN: TP-1502
TP_MODE: TP-1502
TP_PG: TP-1502
TP_VREG: TP-1502
U1: PWP0020P_N
VIN: TP-1502
VOUT: TP-1502

Connections:
0: Cin.2, Cinx.2, Co_sense.2, Cout.2, Cvreg.2, GND.1, GND1.1, Rfbb.2, U1.1, U1.9, U1.13, U1.18, U1.21
5: Cin.1, Cinx.1, U1.4, U1.5, U1.6, VIN.1
6: Cbst2.1, L1.1, U1.20
7: Cbst1.1, L1.2, U1.2
8: Co_sense.1, Cout.1, Rfbt.1, Rpg.1, U1.16, U1.17, VOUT.1
9: Cbst1.2, U1.3
13: TP_Delay.1, U1.10
14: Rpg.2, TP_PG.1, U1.15
15: Rfb.2, Rfbb.1, Rfbt.2, U1.14
17: Cvreg.1, TP_VREG.1, U1.11, U1.12
18: TP_MODE.1, U1.7
20: Cbst2.2, U1.19
21: TP_IGN.1, U1.8
22: Rfb.1, TP_FB.1

## Code that names these connections

File W-BT.X/mcc_generated_files/pin_manager.h (part):

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*/
/**
  @Summary
    Sets the GPIO pin, RA0, high using LATA0.

  @Description
    Sets the GPIO pin, RA0, high using LATA0.

  @Preconditions
    The RA0 must be set to an output.
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#define A6_SetHigh()          ( LATASET = (1 << 0) )
/**
  @Summary
    Sets the GPIO pin, RA0, low using LATA0.

  @Description
    Sets the GPIO pin, RA0, low using LATA0.

  @Preconditions
    The RA0 must be set to an output.
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    Sets a value to the GPIO pin.

  @Description
    Sets or Resets the GPIO pin, RA0, low or high using LATA0.

  @Preconditions
    The RA0 must be set to an output.
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
/**
  @Summary
    Toggles the GPIO pin, RA0, using LATA0.

  @Description
    Toggles the GPIO pin, RA0, using LATA0.

  @Preconditions
    The RA0 must be set to an output.
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#define A6_Toggle()           ( LATAINV = (1 << 0) )
/**
  @Summary
    Reads the value of the GPIO pin, RA0.

  @Description
    Reads the value of the GPIO pin, RA0.

  @Preconditions
    None.
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    </code>

*/
#define A6_GetValue()         PORTAbits.RA0
/**
  @Summary
    Configures the GPIO pin, RA0, as an input.

  @Description
    Configures the GPIO pin, RA0, as an input.

  @Preconditions
    None.
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#define A6_SetDigitalInput()   ( TRISASET = (1 << 0) )
/**
  @Summary
    Configures the GPIO pin, RA0, as an output.

  @Description
    Configures the GPIO pin, RA0, as an output.

  @Preconditions
    None.
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#define A6_SetDigitalOutput()   ( TRISACLR = (1 << 0) )
/**
  @Summary
    Sets the GPIO pin, RA1, high using LATA1.

  @Description
    Sets the GPIO pin, RA1, high using LATA1.

  @Preconditions
    The RA1 must be set to an output.
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#define A5_SetHigh()          ( LATASET = (1 << 1) )
/**
  @Summary
    Sets the GPIO pin, RA1, low using LATA1.

  @Description
    Sets the GPIO pin, RA1, low using LATA1.

  @Preconditions
    The RA1 must be set to an output.
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    Sets a value to the GPIO pin.

  @Description
    Sets or Resets the GPIO pin, RA1, low or high using LATA1.

  @Preconditions
    The RA1 must be set to an output.
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
/**
  @Summary
    Toggles the GPIO pin, RA1, using LATA1.

  @Description
    Toggles the GPIO pin, RA1, using LATA1.

  @Preconditions
    The RA1 must be set to an output.
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#define A5_Toggle()           ( LATAINV = (1 << 1) )
/**
  @Summary
    Reads the value of the GPIO pin, RA1.

  @Description
    Reads the value of the GPIO pin, RA1.

  @Preconditions
    None.
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    </code>

*/
#define A5_GetValue()         PORTAbits.RA1
/**
  @Summary
    Configures the GPIO pin, RA1, as an input.

  @Description
    Configures the GPIO pin, RA1, as an input.

  @Preconditions
    None.
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#define A5_SetDigitalInput()   ( TRISASET = (1 << 1) )
/**
  @Summary
    Configures the GPIO pin, RA1, as an output.

  @Description
    Configures the GPIO pin, RA1, as an output.

  @Preconditions
    None.
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#define A5_SetDigitalOutput()   ( TRISACLR = (1 << 1) )
/**
  @Summary
    Sets the GPIO pin, RA2, high using LATA2.

  @Description
    Sets the GPIO pin, RA2, high using LATA2.

  @Preconditions
    The RA2 must be set to an output.
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#define A2_SetHigh()          ( LATASET = (1 << 2) )
/**
  @Summary
    Sets the GPIO pin, RA2, low using LATA2.

  @Description
    Sets the GPIO pin, RA2, low using LATA2.

  @Preconditions
    The RA2 must be set to an output.
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    Sets a value to the GPIO pin.

  @Description
    Sets or Resets the GPIO pin, RA2, low or high using LATA2.

  @Preconditions
    The RA2 must be set to an output.
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
/**
  @Summary
    Toggles the GPIO pin, RA2, using LATA2.

  @Description
    Toggles the GPIO pin, RA2, using LATA2.

  @Preconditions
    The RA2 must be set to an output.
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#define A2_Toggle()           ( LATAINV = (1 << 2) )
/**
  @Summary
    Reads the value of the GPIO pin, RA2.

  @Description
    Reads the value of the GPIO pin, RA2.

  @Preconditions
    None.
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    </code>

*/
#define A2_GetValue()         PORTAbits.RA2
/**
  @Summary
    Configures the GPIO pin, RA2, as an input.

  @Description
    Configures the GPIO pin, RA2, as an input.

  @Preconditions
    None.
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#define A2_SetDigitalInput()   ( TRISASET = (1 << 2) )
/**
  @Summary
    Configures the GPIO pin, RA2, as an output.

  @Description
    Configures the GPIO pin, RA2, as an output.

  @Preconditions
    None.
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#define A2_SetDigitalOutput()   ( TRISACLR = (1 << 2) )
/**
  @Summary
    Sets the GPIO pin, RA3, high using LATA3.

  @Description
    Sets the GPIO pin, RA3, high using LATA3.

  @Preconditions
    The RA3 must be set to an output.
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#define A1_SetHigh()          ( LATASET = (1 << 3) )
/**
  @Summary
    Sets the GPIO pin, RA3, low using LATA3.

  @Description
    Sets the GPIO pin, RA3, low using LATA3.

  @Preconditions
    The RA3 must be set to an output.
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    Sets a value to the GPIO pin.

  @Description
    Sets or Resets the GPIO pin, RA3, low or high using LATA3.

  @Preconditions
    The RA3 must be set to an output.
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
/**
  @Summary
    Toggles the GPIO pin, RA3, using LATA3.

  @Description
    Toggles the GPIO pin, RA3, using LATA3.

  @Preconditions
    The RA3 must be set to an output.
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#define A1_Toggle()           ( LATAINV = (1 << 3) )
/**
  @Summary
    Reads the value of the GPIO pin, RA3.

  @Description
    Reads the value of the GPIO pin, RA3.

  @Preconditions
    None.
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    </code>

*/
#define A1_GetValue()         PORTAbits.RA3
/**
  @Summary
    Configures the GPIO pin, RA3, as an input.

  @Description
    Configures the GPIO pin, RA3, as an input.

  @Preconditions
    None.
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#define A1_SetDigitalInput()   ( TRISASET = (1 << 3) )
/**
  @Summary
    Configures the GPIO pin, RA3, as an output.

  @Description
    Configures the GPIO pin, RA3, as an output.

  @Preconditions
    None.
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#define A1_SetDigitalOutput()   ( TRISACLR = (1 << 3) )
/**
  @Summary
    Sets the GPIO pin, RA4, high using LATA4.

  @Description
    Sets the GPIO pin, RA4, high using LATA4.

  @Preconditions
    The RA4 must be set to an output.
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#define O2_SetHigh()          ( LATASET = (1 << 4) )
/**
  @Summary
    Sets the GPIO pin, RA4, low using LATA4.

  @Description
    Sets the GPIO pin, RA4, low using LATA4.

  @Preconditions
    The RA4 must be set to an output.
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    Sets a value to the GPIO pin.

  @Description
    Sets or Resets the GPIO pin, RA4, low or high using LATA4.

  @Preconditions
    The RA4 must be set to an output.
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
/**
  @Summary
    Toggles the GPIO pin, RA4, using LATA4.

  @Description
    Toggles the GPIO pin, RA4, using LATA4.

  @Preconditions
    The RA4 must be set to an output.
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#define O2_Toggle()           ( LATAINV = (1 << 4) )
/**
  @Summary
    Reads the value of the GPIO pin, RA4.

  @Description
    Reads the value of the GPIO pin, RA4.

  @Preconditions
    None.
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    </code>

*/
#define O2_GetValue()         PORTAbits.RA4
/**
  @Summary
    Configures the GPIO pin, RA4, as an input.

  @Description
    Configures the GPIO pin, RA4, as an input.

  @Preconditions
    None.
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#define O2_SetDigitalInput()   ( TRISASET = (1 << 4) )
/**
  @Summary
    Configures the GPIO pin, RA4, as an output.

  @Description
    Configures the GPIO pin, RA4, as an output.

  @Preconditions
    None.
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#define O2_SetDigitalOutput()   ( TRISACLR = (1 << 4) )
/**
  @Summary
    Sets the GPIO pin, RB10, high using LATB10.

  @Description
    Sets the GPIO pin, RB10, high using LATB10.

  @Preconditions
    The RB10 must be set to an output.
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#define I1_SetHigh()          ( LATBSET = (1 << 10) )
/**
  @Summary
    Sets the GPIO pin, RB10, low using LATB10.

  @Description
    Sets the GPIO pin, RB10, low using LATB10.

  @Preconditions
    The RB10 must be set to an output.
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    Sets a value to the GPIO pin.

  @Description
    Sets or Resets the GPIO pin, RB10, low or high using LATB10.

  @Preconditions
    The RB10 must be set to an output.
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
/**
  @Summary
    Toggles the GPIO pin, RB10, using LATB10.

  @Description
    Toggles the GPIO pin, RB10, using LATB10.

  @Preconditions
    The RB10 must be set to an output.
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#define I1_Toggle()           ( LATBINV = (1 << 10) )
/**
  @Summary
    Reads the value of the GPIO pin, RB10.

  @Description
    Reads the value of the GPIO pin, RB10.

  @Preconditions
    None.
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    </code>

*/
#define I1_GetValue()         PORTBbits.RB10
/**
  @Summary
    Configures the GPIO pin, RB10, as an input.

  @Description
    Configures the GPIO pin, RB10, as an input.

  @Preconditions
    None.
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#define I1_SetDigitalInput()   ( TRISBSET = (1 << 10) )
/**
  @Summary
    Configures the GPIO pin, RB10, as an output.

  @Description
    Configures the GPIO pin, RB10, as an output.

  @Preconditions
    None.
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#define I1_SetDigitalOutput()   ( TRISBCLR = (1 << 10) )
/**
  @Summary
    Sets the GPIO pin, RB11, high using LATB11.

  @Description
    Sets the GPIO pin, RB11, high using LATB11.

  @Preconditions
    The RB11 must be set to an output.
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#define I2_SetHigh()          ( LATBSET = (1 << 11) )
/**
  @Summary
    Sets the GPIO pin, RB11, low using LATB11.

  @Description
    Sets the GPIO pin, RB11, low using LATB11.

  @Preconditions
    The RB11 must be set to an output.
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
## Commit log

2020-08-22 first
2021-02-03 README

Notices in the files:
W-BT.X/mcc_generated_files/pin_manager.h:
(c) 2020 Microchip Technology Inc. and its subsidiaries. You may use this
